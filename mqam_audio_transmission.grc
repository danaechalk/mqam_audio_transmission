options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable_qtgui_chooser
  parameters:
    label: Modulation order
    label0: BPSK
    label1: QPSK
    label2: 8-PSK
    label3: 16-QAM
    num_opts: '4'
    option0: '2'
    option1: '4'
    option2: '8'
    option3: '16'
    type: int
    value: '4'
  states: {}
- name: k_bits
  id: variable
  parameters:
    value: int(math.log(M, 2))
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.05'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '{2:[-1,1],4:[-1-1j, -1+1j, 1-1j, 1+1j],8:[1,0,1,1j,0.707+0.707j,0.707-0.707j,-0.707+0.707j,-0.707-0.707j],16:[-3-3j,-3-1j,-3+1j,-3+3j,-1-3j,-1-1j,-1+1j,-1+3j,1-3j, 1-1j, 1+1j, 1+3j, 3-3j, 3-1j, 3+1j, 3+3j]}[M]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: list(range(M))
    type: calcdist
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: k_bits
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\file_example_WAV_5MG.wav
    repeat: 'False'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: variable_constellation_0.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: variable_constellation_0
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    B: '8'
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self, mu=255, B=8):\n        gr.sync_block.__init__(self,\n            name=\"mu_law_compand_quantize\",\n            in_sig=[np.float32],\n            out_sig=[np.uint8])\n        self.mu = float(mu)\n        self.B = int(B)\n        self.levels = 2**self.B\n\n    def compand(self, x):\n        sign = np.sign(x)\n        ax = np.abs(x)\n        y = sign * (np.log(1 + self.mu * ax) / np.log(1 + self.mu))\n        return y\n\n    def quantize(self, y):\n        y_clip = np.clip(y, -1.0, 1.0)\n        q = ((y_clip + 1.0) / 2.0) * (self.levels - 1)\n        return np.round(q).astype(np.uint8)\n\n    def work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n        y = self.compand(inp)\n        q = self.quantize(y)\n        out[:len(q)] = q\n        return len(q)\n\n"
    mu: '255'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nMU = 255.0\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"mu-law decoder\",\n            in_sig=[np.uint8],    # byte input\n            out_sig=[np.float32], # float output\n        )\n\n    def work(self, input_items, output_items):\n        y = input_items[0].astype(np.float32)\n\n        # scale bytes 0-255 → [-1, 1]\n        y = (y - 128.0) / 128.0\n\n        # μ-law expansion (inverse)\n        sign = np.sign(y)\n        abs_y = np.abs(y)\n\n        x = sign * (1.0 / MU) * ((1.0 + MU)**abs_y - 1.0)\n\n        output_items[0][:] = x\n        return len(output_items[0])\n\n\n\n"
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: firdes.root_raised_cosine(1.0/math.sqrt(sps), samp_rate, symbol_rate, 0.5, 21*sps)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: 'import numpy '
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: firdes.root_raised_cosine(math.sqrt(sps), samp_rate, symbol_rate, 0.5, 21*sps)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: Modulation Constellation
    size: '2048'
    type: complex
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: firdes.low_pass(1, samp_rate, 3500, 500, window.WIN_HAMMING)
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: v1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: v1
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [channels_channel_model_0, '0', fir_filter_xxx_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [epy_block_0, '0', blocks_char_to_float_0, '0']
- [epy_block_0, '0', blocks_repack_bits_bb_0, '0']
- [epy_block_1, '0', audio_sink_1, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [interp_fir_filter_xxx_1, '0', channels_channel_model_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
